DESCRIPTION = "Simple packagegroup"
LICENSE = "MIT"
SECTION = "mylayer"
PR = "r0"

inherit packagegroup
RDEPENDS:${PN} = "example"
